# Keil uVision project SD.uvproj, settings and files
target DataAcquistionBoard (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: DataAcquisitionBoard +hex
  c flags: Optim=3 wLevel=2
  c define: STM32F40XX,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\SRAM;..\HARDWARE\SDIO;..\SOFTWARE\binrw;..\FWLIB\inc;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\GPS;..\SYSTEM\tick;..\HARDWARE\RTC;..\SYSTEM\counter;..\SOFTWARE\fatfs\src;..\SOFTWARE\fatfs\exfuns;..\HARDWARE\MPU6050;..\HARDWARE\IIC;..\SOFTWARE\fatfs\file_cluster;..\HARDWARE\IWDG;..\HARDWARE\CAN;..\SOFTWARE\malloc;..\SOFTWARE\data_queue;..\HARDWARE\DMA;..\SOFTWARE\gpgga;..\SOFTWARE\quaternions
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/CAN/: can.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/tick/: tick.c
    ../SYSTEM/counter/: counter.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_can.c stm32f4xx_i2c.c stm32f4xx_tim.c stm32f4xx_dbgmcu.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c
  group SOFTWARE
    ../SOFTWARE/binrw/: bin_writer.c
    ../SOFTWARE/gpgga/: nmea_0183.c
    ../SOFTWARE/quaternions/: quaternions.c
  group FATFS
    ../SOFTWARE/fatfs/exfuns/: exfuns.c fattester.c
    ../SOFTWARE/fatfs/src/: diskio.c ff.c
    ../SOFTWARE/fatfs/src/option/: cc936.c
    ../SOFTWARE/fatfs/file_cluster/: file_cluster.c
    ../SOFTWARE/malloc/: malloc.c
  group MPUDMP
    ../HARDWARE/MPU6050/: mpu6050.c hardiic.c mpu_data_acq.c
    ../HARDWARE/IIC/: myiic.c
